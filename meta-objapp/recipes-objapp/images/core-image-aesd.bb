inherit core-image
CORE_IMAGE_EXTRA_INSTALL += "objapp"
inherit extrausers

